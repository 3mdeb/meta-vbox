COMPATIBLE_MACHINE_vbox = "${MACHINE}"
